# Keil uVision project IIC_SPI_OLED_AHT_CubeMX.uvprojx, settings and files
target IIC_SPI_OLED_AHT_CubeMX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: IIC_SPI_OLED_AHT_CubeMX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;.\OLED_HAL;.\AHT20_HAL;.\UCOS\uC-BSP;.\UCOS\uC-CONFIG;.\UCOS\uC-CPU;.\UCOS\uC-CPU\ARM-Cortex-M3\RealView;.\UCOS\uC-LIB;.\UCOS\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOS\uCOS-III\Ports;.\UCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\UCOS\uCOS-III\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group AHT20_HAL
    ./AHT20_HAL/: AHT20.c AHT20.h
  group OLED_HAL
    ./OLED_HAL/: bmp.h gui.c gui.h oled.c oled.h oledfont.h
  group CPU
    ./UCOS/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ./UCOS/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group LIB
    ./UCOS/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ./UCOS/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group PORT
    ./UCOS/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group SOURCE
    ./UCOS/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group CONFIG
    ./UCOS/uC-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ./UCOS/uC-BSP/: bsp.c bsp.h
software components: CMSIS:CORE 4.3.0
